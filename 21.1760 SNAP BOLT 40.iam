# Autodesk Inventor assembly: 21.1760 SNAP BOLT 40
## iProperties
Created: 2007-01
Part Number: 21.1760 SNAP BOLT 40
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
